IMAGE_INSTALL += " \
    nodejs-npm \
    ppp \
"
